<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LPTIM1_Stop_Wakeup.ewp</path>
    </project>
    <batchBuild />
</workspace>
