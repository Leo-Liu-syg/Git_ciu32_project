# IAR project LCD_InnerRes_LowDrive_Pon_4COM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CIU32L051R8Tx HED CIU32L051R8Tx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CIU32L051
  ICCARM.CCIncludePath2: ..\Include; ..\..\..\..\Drivers\CIU32L051_Lib\Include; ..\..\..\..\Drivers\CMSIS\Core; ..\..\..\..\Drivers\CMSIS\Device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LCD_InnerRes_LowDrive_Pon_4COM.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CIU32L051; NDBUG
  group BSP
    ../Source/: common.c lcd_bsp.c lcd_segment_yr1213c.c
  group CIU32L051_Lib
    ../../../../Drivers/CIU32L051_Lib/Source/: ciu32l051_std.c ciu32l051_std_adc.c ciu32l051_std_aes.c ciu32l051_std_comp.c ciu32l051_std_crc.c ciu32l051_std_dma.c ciu32l051_std_exti.c ciu32l051_std_flash.c ciu32l051_std_gpio.c ciu32l051_std_i2c.c ciu32l051_std_lcd.c ciu32l051_std_lptim.c ciu32l051_std_lpuart.c ciu32l051_std_pmu.c ciu32l051_std_rcc.c ciu32l051_std_rtc.c ciu32l051_std_spi.c ciu32l051_std_tamp.c ciu32l051_std_tim.c ciu32l051_std_trng.c ciu32l051_std_usart.c
  group CMSIS
    ../../../../Drivers/CMSIS/Device/: system_ciu32l051.c
  group Doc
    ../: readme.txt
  group Startup
    ./: startup_ciu32l051.s
  group User
    ../Source/: main.c
