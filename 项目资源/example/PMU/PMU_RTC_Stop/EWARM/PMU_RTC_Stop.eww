<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PMU_RTC_Stop.ewp</path>
    </project>
    <batchBuild />
</workspace>
