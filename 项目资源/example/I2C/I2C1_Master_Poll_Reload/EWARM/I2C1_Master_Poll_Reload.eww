<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\I2C1_Master_Poll_Reload.ewp</path>
    </project>
    <batchBuild />
</workspace>
