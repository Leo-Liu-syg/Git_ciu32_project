# Keil uVision project LCD_InnerRes_HighDrive_4COM.uvprojx, settings and files
target LCD_InnerRes_HighDrive_4COM (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: CIU32L051C8Tx HED
  pack: HED.CIU32L0xx_DFP.1.2.5
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LCD_InnerRes_HighDrive_4COM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CIU32L051
  c include: ..\Include;..\..\..\..\Drivers\CIU32L051_Lib\Include;..\..\..\..\Drivers\CMSIS\Core;..\..\..\..\Drivers\CMSIS\Device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../Source/: LED.c LED.h main.c main.h ssc.c ssc.h nivc.c nivc.h timer8.c timer8.h gpio.c gpio.h LCD.c LCD.h adc.c adc.h timer3.c timer3.h app.c app.h Flash.c Flash.h i2c.c i2c.h
  group CIU32L051_Lib
    ../../../../Drivers/CIU32L051_Lib/Source/: ciu32l051_std.c ciu32l051_std_adc.c ciu32l051_std_aes.c ciu32l051_std_comp.c ciu32l051_std_crc.c ciu32l051_std_dma.c ciu32l051_std_exti.c ciu32l051_std_flash.c ciu32l051_std_gpio.c ciu32l051_std_i2c.c ciu32l051_std_lcd.c ciu32l051_std_lptim.c ciu32l051_std_lpuart.c ciu32l051_std_pmu.c ciu32l051_std_rcc.c ciu32l051_std_rtc.c ciu32l051_std_spi.c ciu32l051_std_tamp.c ciu32l051_std_tim.c ciu32l051_std_trng.c ciu32l051_std_usart.c
  group CMSIS
    ../../../../Drivers/CMSIS/Device/: system_ciu32l051.c
  group Startup
    ./: startup_ciu32l051.s
