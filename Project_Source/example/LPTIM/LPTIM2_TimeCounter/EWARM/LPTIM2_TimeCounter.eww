<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LPTIM2_TimeCounter.ewp</path>
    </project>
    <batchBuild />
</workspace>
