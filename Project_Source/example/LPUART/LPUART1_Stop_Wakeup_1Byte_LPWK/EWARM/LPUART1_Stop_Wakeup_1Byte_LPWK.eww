<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LPUART1_Stop_Wakeup_1Byte_LPWK.ewp</path>
    </project>
    <batchBuild />
</workspace>
