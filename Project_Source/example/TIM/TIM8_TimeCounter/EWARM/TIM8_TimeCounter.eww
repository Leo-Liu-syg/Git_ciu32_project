<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TIM8_TimeCounter.ewp</path>
    </project>
    <batchBuild />
</workspace>
