<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\COMP_6BIT_DAC_VS_VBGR_Window.ewp</path>
    </project>
    <batchBuild />
</workspace>
