# Keil uVision project Flash_PageErase_FastProgram.uvprojx, settings and files
target Flash_PageErase_FastProgram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: CIU32L051R8Tx HED
  pack: HED.CIU32L0xx_DFP.1.2.5
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Flash_PageErase_FastProgram +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CIU32L051
  c include: ..\Include;..\..\..\..\Drivers\CIU32L051_Lib\Include;..\..\..\..\Drivers\CMSIS\Core;..\..\..\..\Drivers\CMSIS\Device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Flash_PageErase_FastProgram.sct
  group User
    ../Source/: main.c
  group BSP
    ../Source/: common.c flash_bsp.c
  group CIU32L051_Lib
    ../../../../Drivers/CIU32L051_Lib/Source/: ciu32l051_std.c ciu32l051_std_adc.c ciu32l051_std_aes.c ciu32l051_std_comp.c ciu32l051_std_crc.c ciu32l051_std_dma.c ciu32l051_std_exti.c ciu32l051_std_flash.c ciu32l051_std_gpio.c ciu32l051_std_i2c.c ciu32l051_std_lcd.c ciu32l051_std_lptim.c ciu32l051_std_lpuart.c ciu32l051_std_pmu.c ciu32l051_std_rcc.c ciu32l051_std_rtc.c ciu32l051_std_spi.c ciu32l051_std_tamp.c ciu32l051_std_tim.c ciu32l051_std_trng.c ciu32l051_std_usart.c
  group CMSIS
    ../../../../Drivers/CMSIS/Device/: system_ciu32l051.c
  group Startup
    ./: startup_ciu32l051.s
  group Doc
    ../: readme.txt
