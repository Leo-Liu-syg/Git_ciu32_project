<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\USART1_Smartcard.ewp</path>
    </project>
    <batchBuild />
</workspace>
