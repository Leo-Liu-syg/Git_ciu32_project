<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LCD_ChargePump_4COM.ewp</path>
    </project>
    <batchBuild />
</workspace>
