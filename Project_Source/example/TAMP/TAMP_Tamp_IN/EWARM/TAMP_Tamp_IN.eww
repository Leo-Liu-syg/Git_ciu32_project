<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TAMP_Tamp_IN.ewp</path>
    </project>
    <batchBuild />
</workspace>
